# Keil uVision project compassboard.uvproj, settings and files
target compassboard (ARM-ADS)
  device: LPC2366 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: compassboard +hex
  AfterMake: C:\Keil_v5\ARM\BIN\ELFDWT.EXE !L
  c flags: Optim=3
  c define: xDEVELOPMENT
  c include: C:\Keil_v5\ARM\INC\Phillips
  memory RVCT4: ROM 0x0 size 0x3d000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group Code
    ./: irq.c main.c PLL.c retarget.c serial.c serialDebug.c timer.c gpio.c i2c.c compass.c MPU9250.c quaternionFilters.c spiflash.c ssp.c storedconfig.c
